Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilets_Ceramica-Catalano_Sfera-54-NewFlush-Wall-Hung-WC.ifc
Time: 2023-11-23T12:36:18
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Sfera 54 NewFlush Wall-Hung WC
ePset_BIMobjectScript - COLOUR_WC: Glossy_White; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Sfera 54 NewFlush Wall-Hung WC; SKU (BO_prodsku): catalano_wc_sfera_NF_54X35_cod_1VSF54R00; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; ProductFamily (BO_prodfam): Sfera; ProductGroup (BO_prodgroup): WC; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 9/8/2017; EditionNumber (BO_edinum): 1; Width (BO_width): 540; Height (BO_height): 410; Depth (BO_depth): 350; Weight (BO_weight): 24; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/catalano_wc_sfera_NF_54X35_cod_1VSF54R00; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/catalano_wc_sfera_NF_54X35_cod_1VSF54R00; ProductUrl (BO_producturl): http://www.catalano.it/it/prodotti/sfera/sfera-wc-newflush-bidet-54x35-1vsf54r00-1bsf5400/; InstallationInstructions (BO_montins): https://www.youtube.com/watch?v=yhsBXQb1Pz0; ProductCertification (BO_prodcert): http://www.ceramicacatalano.it/conformita/Declaration-of-Performance-Wc.pdf; TechnicalDescription (BO_techcert): http://www.ceramicacatalano.it/allegati_schede/schede-tecniche/SFERA/1VSF54R00.pdf; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=DYHjv-EQFzc; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Vitreous china; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilets; BimObjectCategoryCode (BO_bocat_code): toilets; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass14Code (BO_uniclass_1_4_code): L7216; Uniclass14Description (BO_uniclass_1_4_desc): Toilets; Uniclass20Code (BO_uniclass_2_0_code): SS-35-65-90; Uniclass20Description (BO_uniclass_2_0_desc): Toilet Systems; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_93_94; Uniclass2015Description (BO_uniclass2015_desc): WC pans; NBSReference (BO_nbs_ref): 31-75; NBSReferenceDescription (BO_nbs_desc): Sanitary Accessories; OmniClassCode (BO_omniclass_code): 23-31 19 00; OmniClassDescription (BO_omniclass_name): Toilets; MasterFormat2014Code (BO_masterformat2014_code): 10 06 20.13; MasterFormat2014Description (BO_masterformat2014_name): Toilet, Bath, and Laundry Accessory Schedule; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
